Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: BT400L-VO-60X60.IFC
Time: 2019-03-28T13:47:13
Author: com2it
Organization: Hewlett-Packard Company
Written by: SwIFC
Made in: SolidWorks 2015

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: BT50-EX-VO-60-A (2)
In: Default Storey
Name
BT50-EX-VO-60-A | PSet_Mass_Property - Mass Measure: 17.8684; Area Measure: 1.54565 m2; Volume Measure: 0.00229069 m3
BT50-EX-VO-60-A
